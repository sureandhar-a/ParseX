<?xml version="1.0" encoding="utf-8"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-2-2.xsd">
  <!-- Deliberately broken companion to sample.arxml: the package is missing
       its required SHORT-NAME, so validation reports a schema error. -->
  <AR-PACKAGES>
    <AR-PACKAGE>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
