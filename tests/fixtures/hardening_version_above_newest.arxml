<?xml version="1.0" encoding="UTF-8"?>
<!-- Boundary probe: just above newest supported (00099 does not exist).
     Must reject with a specific unsupported-release error. -->
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00099.xsd">
    <AR-PACKAGES><AR-PACKAGE><SHORT-NAME>System</SHORT-NAME><ELEMENTS/></AR-PACKAGE></AR-PACKAGES>
</AUTOSAR>
